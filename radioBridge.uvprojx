# Keil uVision project radioBridge.uvprojx, settings and files
target rfBridge (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: radioBridge
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\freeRTOS\include;.\Adafruit_GFX_Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./src/: main.c timertest.c ui.c
  group freeRTOS
    ./freeRTOS/: croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c heap_2.c
    ./src/: keys.c
  group lcd
    ./Adafruit_GFX_Library/: Adafruit_GFX.c glcdfont.c
    ./MCUFRIEND_kbv/: MCUFRIEND_kbv.c.txt
    ./src/: tft_lcd.c
software components: CMSIS:CORE 5.0.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
